# Keil uVision project Blinky.uvprojx, settings and files
target NUCLEO-H563ZI (6190000::V6.19::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Blinky
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  scatter file: .\RTE\Device\STM32H563ZITx\stm32h563xx_flash.sct
  group App
    ./: Blinky.c
  group Documentation
    ./: README.md
  group :STM32CubeMX:Common Sources
    ./Board/NUCLEO-H563ZI/STM32CubeMX/Src/: main.c stm32h5xx_it.c
    ./Board/NUCLEO-H563ZI/STM32CubeMX/Inc/: stm32h5xx_it.h
    ./Board/NUCLEO-H563ZI/STM32CubeMX/: STM32CubeMX.ioc
software components: CMSIS:CORE 5.6.0, CMSIS:RTOS2:Keil RTX5 5.5.4, Compiler:Event Recorder 1.5.1, Board Support:Drivers:Basic I/O 1.0.0, CMSIS Driver:VIO:Board 1.0.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:EXTI 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:ICACHE 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:Startup 1.1.0
