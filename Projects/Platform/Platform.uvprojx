# Keil uVision project Platform.uvprojx, settings and files
target NUCLEO-H563ZI (6210000::V6.21::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: image
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: .\Board
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  scatter file: .\RTE\Device\STM32H563ZITx\stm32h563xx_flash.sct
  group App
    ./: Platform.c
  group Board
    ./Board/NUCLEO-H563ZI/: arduino.c arduino.h retarget_stdio.c
  group Documentation
    ./: README.md
    ./Board/NUCLEO-H563ZI/STM32CubeMX/: STM32CubeMX.pdf
  group :STM32CubeMX:Common Sources
    ./Board/NUCLEO-H563ZI/STM32CubeMX/Src/: main.c stm32h5xx_it.c
    ./Board/NUCLEO-H563ZI/STM32CubeMX/Inc/: stm32h5xx_it.h
    ./Board/NUCLEO-H563ZI/STM32CubeMX/: STM32CubeMX.ioc
software components: CMSIS-Compiler:CORE 1.0.0, CMSIS-Compiler:STDERR:Custom 1.0.0, CMSIS-Compiler:STDIN:Custom 1.0.0, CMSIS-Compiler:STDOUT:Custom 1.0.0, CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Drivers:Basic I/O 1.0.1, CMSIS Driver:Ethernet MAC 1.0.0, CMSIS Driver:Ethernet PHY:LAN8742A 1.3.0, CMSIS Driver:SPI 1.0.0, CMSIS Driver:USART 1.0.0, CMSIS Driver:USB Device:Full-speed 1.1.0, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube Framework:STM32CubeMX 2.0.0, Device:STM32Cube HAL:ADC 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:ETH 1.1.0, Device:STM32Cube HAL:EXTI 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:ICACHE 1.1.0, Device:STM32Cube HAL:IRDA 1.1.0, Device:STM32Cube HAL:PCD 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:SPI 1.1.0, Device:STM32Cube HAL:Smartcard 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube HAL:USART 1.1.0, Device:Startup 1.1.0
