# Keil uVision project MassStorage.uvprojx, settings and files
target Debug (6210000::V6.21::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: IRAM(0x20000000,0x00050000) IRAM2(0x20050000,0x00050000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: MassStorage
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  scatter file: .\RTE\Device\STM32H563ZITx\stm32h563xx_flash.sct
  group Source
    ./: MassStorage.c MemoryDiskImage.c USBD_User_MSC_0.c
  group Documentation
    ./: Abstract.txt
  group :STM32CubeMX:Common Sources
    ./Board/NUCLEO-H563ZI/STM32CubeMX/Src/: main.c stm32h5xx_it.c
    ./Board/NUCLEO-H563ZI/STM32CubeMX/Inc/: stm32h5xx_it.h
    ./Board/NUCLEO-H563ZI/STM32CubeMX/: STM32CubeMX.ioc
target Release (6210000::V6.21::ARMCLANG)
  device: STM32H563ZITx STMicroelectronics
  pack: Keil.STM32H5xx_DFP.1.2.0
  cpu: as above
  output: HID
  c flags: Optim=4 OneElfS=1 uC99=1 uGnu=1 v6Lang=5 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x20050000 size 0x50000
  scatter file: .\RTE\Device\STM32H563ZITx\stm32h563xx_flash.sct
  link misc: --diag_suppress=L6314
software components: CMSIS-View:Event Recorder 1.5.3, CMSIS:CORE 6.0.0, CMSIS:OS Tick:SysTick 1.0.5, CMSIS:RTOS2:Keil RTX5 5.8.0, Board Support:Drivers:Basic I/O 1.0.1, CMSIS Driver:USB Device:Full-speed 1.1.0, CMSIS Driver:VIO:Board 2.0.0, Device:STM32Cube Framework:STM32CubeMX 2.0.0, Device:STM32Cube HAL:ADC 1.1.0, Device:STM32Cube HAL:Common 1.1.0, Device:STM32Cube HAL:Cortex 1.1.0, Device:STM32Cube HAL:DMA 1.1.0, Device:STM32Cube HAL:ETH 1.1.0, Device:STM32Cube HAL:EXTI 1.1.0, Device:STM32Cube HAL:Flash 1.1.0, Device:STM32Cube HAL:GPIO 1.1.0, Device:STM32Cube HAL:ICACHE 1.1.0, Device:STM32Cube HAL:PCD 1.1.0, Device:STM32Cube HAL:PWR 1.1.0, Device:STM32Cube HAL:RCC 1.1.0, Device:STM32Cube HAL:UART 1.1.0, Device:STM32Cube LL:Common 1.1.0, Device:STM32Cube LL:GPIO 1.1.0, Device:STM32Cube LL:PWR 1.1.0, Device:STM32Cube LL:RCC 1.1.0, Device:STM32Cube LL:UCPD 1.1.0, Device:STM32Cube LL:UTILS 1.1.0, Device:Startup 1.1.0, USB:CORE 6.17.0, USB:CORE 6.17.0, USB:Device:MSC 6.17.0, USB:Device 6.17.0
